# IAR project slave.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F3P STM8S103F3P
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S103
  ICCSTM8.CCIncludePath2: ..\StdPeriph\inc; ..\User; ..\User\Driver; ..\User\HAL; ..\User\Middle
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: slave.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    ./: main.c
  group StdPeriph
    ../StdPeriph/src/: stm8s_clk.c stm8s_gpio.c stm8s_i2c.c stm8s_tim2.c stm8s_uart1.c
  group User/Driver
    ../User/Driver/: button.c ticker.c
  group User/HAL
    ../User/HAL/: eeprom.c gpio.c i2c.c timer.c uart.c
